# Fix for babeltrace LICENSE file - use correct source directory
# The files are in ${WORKDIR}/git not ${WORKDIR}/babeltrace-${PV}

S = "${WORKDIR}/git"

LIC_FILES_CHKSUM = "file://LICENSE;md5=76ba15dd76a248e1dd526bca0e2125fa"
